# Keil uVision project BH-F103.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\DELAY;..\..\User\SysTick;..\..\User\LED;..\..\User\USART;..\..\User\MATRIX_KEY;..\..\User\FYU43T4827;..\..\User\LOCK_DISPALY;..\..\User\28BYJ;..\..\User\GENERAL_TIM\TIMING;..\..\User\GPIO_INTERP;..\..\User\HT1261;..\..\User\PWM;..\..\User\MG90S
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/DELAY/: delay.c
    ../../User/LED/: led.c
    ../../User/USART/: usart.c
    ../../User/SYSTICK/: systick.c
    ../../User/MATRIX_KEY/: matrix_key.c
    ../../User/FYU43T4827/: fyu43t4827.c
    ../../User/LOCK_DISPALY/: lock_display.c
    ../../User/28BYJ/: 28byj.c
    ../../User/GENERAL_TIM/TIMING/: general_tim.c
    ../../User/GPIO_INTERP/: gpio_interp.c
    ../../User/HT1261/: ht1261.c
    ../../User/PWM/: pwm.c
    ../../User/MG90S/: mg90s.c
  group DOC
    ../../Doc/: readme.txt
