# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Lib\CMSIS;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\LED;..\User\KEY;..\User\DELAY;..\User\DS18B20;..\User\USART;..\User\RCC;..\User\EXIT;..\User\BEEP;..\User\DAM;..\User\ADC;..\User\1602;..\User\28BYJ;..\User\TIM;..\User\SYSTICK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Lib/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/LED/: bsp_led.c
    ../User/KEY/: key.c
    ../User/DELAY/: delay.c
    ../User/DS18B20/: DS18B20.c
    ../User/USART/: USART.c
    ../User/RCC/: RCC.c
    ../User/EXIT/: exit.c
    ../User/BEEP/: beep.c
    ../User/DAM/: dma.c
    ../User/ADC/: adc.c
    ../User/1602/: 1602.c
    ../User/28BYJ/: 28byj.c
    ../User/TIM/: TIM.c
    ../User/SYSTICK/: SYSTICK.c
  group DOC
    ../Doc/: readme.txt
    ./: note.txt
software components: CMSIS:CORE 5.1.1
